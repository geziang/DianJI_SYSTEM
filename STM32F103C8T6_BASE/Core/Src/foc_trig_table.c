/*
 * FOC 三角函数快表实现：256 点 Q15 正弦表 + 线性插值。
 *
 * 表由离线脚本按 sin(i*2pi/256)*32767 四舍五入生成，覆盖一个完整周期，
 * 因此 i+1 回绕到 0 也连续，不需要额外存第 257 点。
 * 归一化刻意不用 floorf/fmod（都是软浮点库调用）：float->long 向零截断后，
 * 只用一次比较+加法修正负角度，代价远低于库函数。
 */

#include <stdint.h>
#include "foc_trig_table.h"

#define FOC_TRIG_N              (256)
#define FOC_TRIG_MASK           (FOC_TRIG_N - 1)
#define FOC_TRIG_QUARTER        (FOC_TRIG_N / 4)      /* pi/2 对应的索引偏移 */
#define FOC_TRIG_Q15_INV_F      (1.0f / 32767.0f)
/* angle(rad) * 本系数 = 相位索引（256 / 2pi）。 */
#define FOC_TRIG_ANGLE_STEP_F   (40.74366543152521f)

static const int16_t foc_trig_sin_q15[FOC_TRIG_N] =
{
       0,    804,   1608,   2410,   3212,   4011,   4808,   5602,
    6393,   7179,   7962,   8739,   9512,  10278,  11039,  11793,
   12539,  13279,  14010,  14732,  15446,  16151,  16846,  17530,
   18204,  18868,  19519,  20159,  20787,  21403,  22005,  22594,
   23170,  23731,  24279,  24811,  25329,  25832,  26319,  26790,
   27245,  27683,  28105,  28510,  28898,  29268,  29621,  29956,
   30273,  30571,  30852,  31113,  31356,  31580,  31785,  31971,
   32137,  32285,  32412,  32521,  32609,  32678,  32728,  32757,
   32767,  32757,  32728,  32678,  32609,  32521,  32412,  32285,
   32137,  31971,  31785,  31580,  31356,  31113,  30852,  30571,
   30273,  29956,  29621,  29268,  28898,  28510,  28105,  27683,
   27245,  26790,  26319,  25832,  25329,  24811,  24279,  23731,
   23170,  22594,  22005,  21403,  20787,  20159,  19519,  18868,
   18204,  17530,  16846,  16151,  15446,  14732,  14010,  13279,
   12539,  11793,  11039,  10278,   9512,   8739,   7962,   7179,
    6393,   5602,   4808,   4011,   3212,   2410,   1608,    804,
       0,   -804,  -1608,  -2410,  -3212,  -4011,  -4808,  -5602,
   -6393,  -7179,  -7962,  -8739,  -9512, -10278, -11039, -11793,
  -12539, -13279, -14010, -14732, -15446, -16151, -16846, -17530,
  -18204, -18868, -19519, -20159, -20787, -21403, -22005, -22594,
  -23170, -23731, -24279, -24811, -25329, -25832, -26319, -26790,
  -27245, -27683, -28105, -28510, -28898, -29268, -29621, -29956,
  -30273, -30571, -30852, -31113, -31356, -31580, -31785, -31971,
  -32137, -32285, -32412, -32521, -32609, -32678, -32728, -32757,
  -32767, -32757, -32728, -32678, -32609, -32521, -32412, -32285,
  -32137, -31971, -31785, -31580, -31356, -31113, -30852, -30571,
  -30273, -29956, -29621, -29268, -28898, -28510, -28105, -27683,
  -27245, -26790, -26319, -25832, -25329, -24811, -24279, -23731,
  -23170, -22594, -22005, -21403, -20787, -20159, -19519, -18868,
  -18204, -17530, -16846, -16151, -15446, -14732, -14010, -13279,
  -12539, -11793, -11039, -10278,  -9512,  -8739,  -7962,  -7179,
   -6393,  -5602,  -4808,  -4011,  -3212,  -2410,  -1608,   -804,
};

/* 按相位索引（可负、可超界，内部折叠）和小数部分做一次线性插值。 */
static float foc_trig_interpolate(long phase_index, float fraction)
{
  uint16_t i0 = (uint16_t)(phase_index & (long)FOC_TRIG_MASK);
  uint16_t i1 = (uint16_t)(((uint16_t)(i0 + 1U)) & FOC_TRIG_MASK);
  float y0;
  float y1;

  /* 整格点直接给精确值，保证自检恒角 0/pi/2/pi/3pi/2 无量化残差。 */
  if (fraction == 0.0f)
  {
    switch (i0)
    {
      case 0:
      case 128:
        return 0.0f;
      case 64:
        return 1.0f;
      case 192:
        return -1.0f;
      default:
        break;
    }
  }

  y0 = (float)foc_trig_sin_q15[i0];
  y1 = (float)foc_trig_sin_q15[i1];
  return (y0 + ((y1 - y0) * fraction)) * FOC_TRIG_Q15_INV_F;
}

void foc_trig_sin_cos(float electrical_angle_rad, float *sine, float *cosine)
{
  float phase = electrical_angle_rad * FOC_TRIG_ANGLE_STEP_F;
  long phase_index = (long)phase;            /* 向零截断，不调用 floorf */
  float fraction = phase - (float)phase_index;

  if ((sine == 0) || (cosine == 0))
  {
    return;
  }

  /* 负角度：截断会留下负小数，平移回 [0,1) 并把索引退一格。 */
  if (fraction < 0.0f)
  {
    fraction += 1.0f;
    phase_index--;
  }

  *sine = foc_trig_interpolate(phase_index, fraction);
  /* cos(theta) = sin(theta + pi/2)：索引偏移 1/4 周期，小数部分相同。 */
  *cosine = foc_trig_interpolate(phase_index + FOC_TRIG_QUARTER, fraction);
}
